# Keil uVision project xkwy.uvprojx, settings and files
target STM32F103RB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xkwy
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Apps;.\Drivers;.\RTE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Apps
    ./Apps/: main.c TaskMgr.c
  group Data
    ./Data/: fonts.c PIC_xkwy.c PIC_main.c PIC_setting.c
  group Drivers
    ./Drivers/: SystemTick.c SoftwareDelay.c Keys.c LED.c ADC.c LCD.c AT24C02.c PWM.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
